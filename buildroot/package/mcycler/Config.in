## buildroot/package/mcycler/Config.in
```kconfig
config BR2_PACKAGE_MCYCLER
	bool "Package mcycler"
	help
	  This is a custom program. Prints current mcycle values
```
